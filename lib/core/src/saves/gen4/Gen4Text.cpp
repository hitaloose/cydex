#include "Gen4Text.h"

#include <cstring>

#include "utils/ByteUtils.h"

namespace {

constexpr uint16_t kFirst = 0x121;
// 0x121..0x1E9 -> Unicode; 0 = sem glifo.
const uint16_t kLatin[] = {
    0x0030, 0x0031, 0x0032, 0x0033, 0x0034, 0x0035, 0x0036, 0x0037,
    0x0038, 0x0039, 0x0041, 0x0042, 0x0043, 0x0044, 0x0045, 0x0046,
    0x0047, 0x0048, 0x0049, 0x004A, 0x004B, 0x004C, 0x004D, 0x004E,
    0x004F, 0x0050, 0x0051, 0x0052, 0x0053, 0x0054, 0x0055, 0x0056,
    0x0057, 0x0058, 0x0059, 0x005A, 0x0061, 0x0062, 0x0063, 0x0064,
    0x0065, 0x0066, 0x0067, 0x0068, 0x0069, 0x006A, 0x006B, 0x006C,
    0x006D, 0x006E, 0x006F, 0x0070, 0x0071, 0x0072, 0x0073, 0x0074,
    0x0075, 0x0076, 0x0077, 0x0078, 0x0079, 0x007A, 0x00C0, 0x00C1,
    0x00C2, 0x00C3, 0x00C4, 0x00C5, 0x00C6, 0x00C7, 0x00C8, 0x00C9,
    0x00CA, 0x00CB, 0x00CC, 0x00CD, 0x00CE, 0x00CF, 0x00D0, 0x00D1,
    0x00D2, 0x00D3, 0x00D4, 0x00D5, 0x00D6, 0x0000, 0x00D8, 0x00D9,
    0x00DA, 0x00DB, 0x00DC, 0x00DD, 0x00DE, 0x00DF, 0x00E0, 0x00E1,
    0x00E2, 0x00E3, 0x00E4, 0x00E5, 0x00E6, 0x00E7, 0x00E8, 0x00E9,
    0x00EA, 0x00EB, 0x00EC, 0x00ED, 0x00EE, 0x00EF, 0x00F0, 0x00F1,
    0x00F2, 0x00F3, 0x00F4, 0x00F5, 0x00F6, 0x0000, 0x00F8, 0x00F9,
    0x00FA, 0x00FB, 0x00FC, 0x00FD, 0x00FE, 0x00FF, 0x0152, 0x0153,
    0x015E, 0x015F, 0x00AA, 0x00BA, 0x0000, 0x0000, 0x0000, 0x0024,
    0x00A1, 0x00BF, 0x0021, 0x003F, 0x002C, 0x002E, 0x0000, 0x0000,
    0x002F, 0x2018, 0x0027, 0x201C, 0x201D, 0x201E, 0x00AB, 0x00BB,
    0x0028, 0x0029, 0x2642, 0x2640, 0x002B, 0x002D, 0x002A, 0x0023,
    0x003D, 0x0026, 0x007E, 0x003A, 0x003B, 0x0000, 0x0000, 0x0000,
    0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0040,
    0x0000, 0x0025, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
    0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0020, 0x0000, 0x0000,
    0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x00B0,
    0x005F,
};
constexpr uint16_t kLast = kFirst + sizeof(kLatin) / sizeof(kLatin[0]) - 1;

uint16_t to_unicode(uint16_t c) {
  if (c >= kFirst && c <= kLast) return kLatin[c - kFirst];
  switch (c) {
    case 0x0E5: return 0x2026;  // …
    case 0x0E7: return '/';
    case 0x0EE: return 0x2642;  // ♂
    case 0x0EF: return 0x2640;  // ♀
    case 0x0F2: return 0xD7;    // ×
    case 0x0F3: return 0xF7;    // ÷
    default: return 0;
  }
}

size_t utf8(uint16_t u, char *out) {
  if (u < 0x80) {
    out[0] = (char)u;
    return 1;
  }
  if (u < 0x800) {
    out[0] = (char)(0xC0 | (u >> 6));
    out[1] = (char)(0x80 | (u & 0x3F));
    return 2;
  }
  out[0] = (char)(0xE0 | (u >> 12));
  out[1] = (char)(0x80 | ((u >> 6) & 0x3F));
  out[2] = (char)(0x80 | (u & 0x3F));
  return 3;
}

}  // namespace

void gen4_text_decode(const uint8_t *data, size_t chars, char *out, size_t out_size) {
  size_t pos = 0;
  for (size_t i = 0; i < chars; i++) {
    uint16_t c = read_u16_le(data + 2 * i);
    if (c == 0xFFFF) break;
    uint16_t u = to_unicode(c);
    char buf[3];
    size_t n = utf8(u ? u : '?', buf);
    if (pos + n >= out_size) break;
    memcpy(out + pos, buf, n);
    pos += n;
  }
  out[pos] = '\0';
}

void gen4_text_encode(const char *text, uint8_t *out, size_t chars) {
  memset(out, 0, chars * 2);
  size_t i = 0;
  for (; text[i] && i + 1 < chars; i++) {
    uint16_t code = 0x1AC;  // ?
    for (uint16_t k = 0; k <= kLast - kFirst; k++) {
      if (kLatin[k] == (uint8_t)text[i]) {
        code = (uint16_t)(kFirst + k);
        break;
      }
    }
    out[2 * i] = (uint8_t)code;
    out[2 * i + 1] = (uint8_t)(code >> 8);
  }
  out[2 * i] = 0xFF;
  out[2 * i + 1] = 0xFF;
}
